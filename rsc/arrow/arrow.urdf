Commit message: enlarged the arrow

File: rsc/arrow/arrow.urdf (robot description, URDF)
Before this commit: robot arrow, 1 links, 0 joints
Links:
- link Untitled: geometry visual mesh filename=Arrow.stl scale=0.015 0.012 0.005
